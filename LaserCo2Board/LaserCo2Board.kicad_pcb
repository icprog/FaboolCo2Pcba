# Repository icprog/FaboolCo2Pcba

File README.md:

# Fabool Laser CO2 PCBA
- Product page: https://www.smartdiys.cc/fabool-laser-co2/
- Shop page: https://shop.smartdiys.cc/collections/co2-laser-cutter-and-engraver
- Manual page: https://www.smartdiys.cc/manual/fabool-laser-co2-2/

## KiCad design LaserCo2Board/LaserCo2Board.kicad_pcb

Parts:
C1, C2, C9, C10: 0u22
C3, C4, C7, C8, C11, C12, C13, C14, C17, C18, C20, C21, C23, C26, C27, C28, C29, C31, C33, C36, C38, C40: 0u1
C5, C6, C39: 100u
C15, C16: 2u2
C19, C22: 20p
C24, C30: 10p
C25: 10u
C32, C34, C37: 10u
C35: 1u
D1: X1 Stop
D2: Y1 Stop
D3: D Stop
D4: X2 Stop
D5: Y2 Stop
D6: VIN
D7: USB
D8: 3.3V
J1: Y VREF
J2: X VREF
J3: JTAG
J4: USB
J5: POWER IN
J6: FAN1
J7: FAN2
J8: FAN3
J9: PUMP
J10: LASER
J11: X MOTOR
J12: Y1 MOTOR
J13: WATER FLOW
J14: Y2 MOTOR
J15: LASER P
J16: X LIMIT1
J17: X LIMIT2
J18: Y LIMIT1
J19: Y LIMIT2
J20: D SWITCH
L1: Ferrite bead
L2: BLM21PG221SN1D
L3, L4: BLM21SN300SN1D
Q1, Q2: BSS138
R1, R3, R5, R12, R13, R14, R15, R19, R20, R21, R22, R23, R24, R29, R30, R37, R38, R42: 10k
R2: 100k; 0603
R4: 100k
R6, R7: 0R
R8, R9, R10, R11: 0R1
R16, R17, R18, R25, R26, R45: 470R
R27, R39, R40: 22R
R28, R31, R43: 4k7
R32: 2k7
R34: 47R
R35, R44: 1k5
R36: 390R
R41: 100R
SW1: SW_PUSH
SW2: SWITCH_INV
TR1: BSH105
U1: STM32F20XR; LQFP64
U2: A4982SLPTR
U3: A4982SLPTR
U4: LD1117S33TR
U5: 74HC08A
U6: MCP4725
U7: MCP44X1
U8: 74HC1G00
VR1, VR2: CG0603MLC-05E
X1: CRYSTAL_4PIN
X2: CRYSTAL

Connections:
+3.3V: C9.1, C10.1, C26.1, C29.1, C31.1, C33.1, C34.1, C36.1, D8.1 (A), J3.1 (VDD), J13.1, L1.1, Q1.G, Q2.G, R2.1, R3.1, R4.1, R5.1, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.1, R20.1, R21.1, R22.1, R23.2, R24.2, R25.2, R26.2, R28.1, R29.2, R31.1, R32.1, R37.2, R42.1, SW2.1, U1.1 (VBAT), U1.19 (VDD_4), U1.32 (VDD_1), U1.48 (VDD_2), U1.64 (VDD_3), U2.5 (MS1), U2.6 (MS2), U2.10 (VDD), U3.5 (MS1), U3.6 (MS2), U3.10 (VDD), U4.2 (OUT1), U4.4 (OUT2), U5.14 (VCC), U7.17 (VDD), U8.5 (VCC)
BOOT0: R12.2, U1.60 (BOOT0)
CHECK_12V: C40.2, R35.1, R36.1, U1.27 (PB1)
D_SWITCH: C20.1, D3.2 (K), J20.1, R15.1, U1.22 (PA6), U8.2 (IN_A)
GND: C1.2, C2.2, C3.1, C4.1, C5.2, C6.2, C9.2, C10.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.1, C38.1, C39.2, C40.1, J3.3 (GND), J3.5 (GND), J3.9 (GND), J4.4 (GND), J6.2 (PM), J7.2 (PM), J8.2 (PM), J9.2 (PM), J10.3, J13.2 (PM), J15.2 (PM), J16.2 (PM), J17.2 (PM), J18.2 (PM), J19.2 (PM), J20.2 (PM), L2.1, L4.1, R1.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R36.2, R43.2, R44.2, R45.2, SW1.1, SW2.3, TR1.S, U1.12 (VSSA), U1.18 (VSS_4), U1.63 (VSS_3), U2.13 (GND), U2.24 (GND), U2.25 (GND_PAD1), U2.26 (GND_PAD2), U3.13 (GND), U3.24 (GND), U3.25 (GND_PAD1), U3.26 (GND_PAD2), U4.1 (GND)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
LASER_ANALOG: J10.2 (PM), U6.1 (OUT)
LASER_OUT: R27.2, TR1.D, U1.39 (PC8)
LASER_OUT_CONN: J10.1, R27.1
unnamed: D2.1 (A), R17.1
unnamed: D1.1 (A), R16.1
unnamed: R42.2, U7.15 (*RESET)
unnamed: R32.2, U7.1 (P3A), U7.10 (P1A)
unnamed: C1.1, U2.4 (VREG)
unnamed: C7.1, U2.3 (VCP)
unnamed: R3.2, U2.7 (/RESET), U2.9 (/SLEEP)
unnamed: R6.1, U2.8 (ROSC)
unnamed: R10.1, U2.17 (SENSE1)
unnamed: R8.1, U2.20 (SENSE2)
unnamed: D3.1 (A), R18.1
unnamed: R41.1, TR1.G
unnamed: R41.2, U8.4 (OUT)
unnamed: C12.2, U3.2 (CP2)
unnamed: C12.1, U3.1 (CP1)
unnamed: C11.2, U2.2 (CP2)
unnamed: C11.1, U2.1 (CP1)
unnamed: D6.2 (K), R43.1
unnamed: D8.2 (K), R45.1
unnamed: J5.2 (PM), L4.2
unnamed: J5.1, L3.2
unnamed: R5.2, U3.7 (/RESET), U3.9 (/SLEEP)
unnamed: R9.1, U3.20 (SENSE2)
unnamed: R11.1, U3.17 (SENSE1)
unnamed: C2.1, U3.4 (VREG)
unnamed: R7.1, U3.8 (ROSC)
unnamed: C8.1, U3.3 (VCP)
unnamed: U5.3 (Y1), U5.9 (A3)
unnamed: U5.6 (Y2), U5.10 (B3)
unnamed: J4.5 (Shield_1), J4.6 (Shield_2), L2.2, VR1.1, VR2.1
unnamed: D4.1 (A), R25.1
unnamed: D5.1 (A), R26.1
unnamed: J15.1, R34.2
unnamed: Q1.D, R30.1, U6.5 (SCL)
unnamed: Q2.D, R38.1, U6.4 (SDA)
unnamed: J4.2 (D-), R40.1, VR2.2
unnamed: C16.1, U1.47 (VCAP_2)
unnamed: C15.1, U1.31 (VCAP_1)
unnamed: D7.2 (K), R44.1
unnamed: J4.3 (D+), R39.1, VR1.2
unnamed: R12.1, SW2.2
unnamed: R1.1, U1.28 (PB2)
unnamed: U5.8 (Y3), U8.1 (IN_B)
OSC32_IN: C24.1, U1.3 (PC14), X2.1
OSC32_OUT: C30.1, U1.4 (PC15), X2.2
OSC_IN: C19.1, U1.5 (PH0/OSC_IN), X1.1
OSC_OUT: C22.1, U1.6 (PH1/OSC_OUT), X1.3
RESET: C21.1, J3.10 (*RST), SW1.2, U1.7 (NRST)
SCL0: R28.2, U1.58 (PB6), U7.5 (SCL)
SCL1: Q1.S, R29.1, U1.41 (PA8)
SDA0: R31.2, U1.59 (PB7), U7.6 (SDA)
SDA1: Q2.S, R37.1, U1.40 (PC9)
TCK: J3.4 (TCK), R21.2, U1.49 (JTCK/SWCLK/PA14)
TDI: J3.8 (TDI), R19.2, U1.50 (JTDI/PA15)
TDO: J3.6 (TDO), R20.2, U1.55 (JTDO/TRACESSW0/PB3)
TMS: J3.2 (TMS), R22.2, U1.46 (JTMS/SWDIO/PA13)
USBM: R40.2, U1.44 (PA11)
USBP: R39.2, U1.45 (PA12)
VBUS: C32.1, C35.1, C37.2, C38.2, D7.1 (A), J4.1 (Vbus), R30.2, R34.1, R38.2, U4.3 (IN), U6.3 (VCC)
VDDA: C23.1, C25.1, L1.2, U1.13 (VDDA)
V_IN: C3.2, C4.2, C5.1, C6.1, C7.2, C8.2, C39.1, D6.1 (A), J6.1, J7.1, J8.1, J9.1, L3.1, R35.2, U2.16 (VBB1), U2.21 (VBB2), U3.16 (VBB1), U3.21 (VBB2)
WATER_FLOW: J13.3, U1.33 (PB12)
X_DIR: U1.9 (PC1), U3.14 (DIR)
X_EN: R4.2, U1.10 (PC2), U3.23 (/ENABLE)
X_LIMIT1: C17.1, D1.2 (K), J16.1, R14.1, U1.15 (PA1), U5.1 (A1)
X_LIMIT2: C27.1, D4.2 (K), J17.1, R24.1, U1.16 (PA2), U5.2 (B1)
X_MOT_1A: J11.3, U3.18 (OUT1A)
X_MOT_1B: J11.4, U3.15 (OUT1B)
X_MOT_2A: J11.2, U3.19 (OUT2A)
X_MOT_2B: J11.1, U3.22 (OUT2B)
X_REF: C14.1, J2.1, U3.12 (REF), U7.9 (P1W)
X_STEP: U1.8 (PC0), U3.11 (STEP)
Y_DIR: U1.25 (PC5), U2.14 (DIR)
Y_EN: R2.2, U1.37 (PC6), U2.23 (/ENABLE)
Y_LIMIT1: C18.1, D2.2 (K), J18.1, R13.1, U1.20 (PA4), U5.4 (A2)
Y_LIMIT2: C28.1, D5.2 (K), J19.1, R23.1, U1.21 (PA5), U5.5 (B2)
Y_MOT_1A: J12.3, J14.3, U2.18 (OUT1A)
Y_MOT_1B: J12.4, J14.4, U2.15 (OUT1B)
Y_MOT_2A: J12.2, J14.2, U2.19 (OUT2A)
Y_MOT_2B: J12.1, J14.1, U2.22 (OUT2B)
Y_REF: C13.1, J1.1, U2.12 (REF), U7.2 (P3W)
Y_STEP: U1.24 (PC4), U2.11 (STEP)

Notes on the sheet:
Power LEDs
Blue
Green
2k7 resistor chosen to give range of VRef with 0R1 sense resistors for full range of current, to use the maximum current cooling would be required.
Endstops
Digital Current Limit Control
Y-Axis Stepper Driver
X-Axis Stepper Driver
USB
Laser signal out
Connector
Red
Analog Output
12V Input

Board: 2 copper layers, 106.8 x 58.5 mm, 133 parts (0 on the bottom side), 90 nets.

File LaserCo2Board BOM.xlsx:

| Part / Value | Package | Manufacturer | Part No | Circuit Reference | Qty | URL
 | LD1117 | SOT-223 | STMicroelectronics | LD1117S33TR | U4 | 1 | http://www.digikey.jp/product-detail/ja/stmicroelectronics/L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
 | 74HC08A | TSSOP-14 | ON Semiconductor | MC74HC08ADTR2G | U5 | 1 | http://www.digikey.jp/product-detail/ja/on-semiconductor/MC7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
 | 74HC1G00 | TSOP-5 | ON Semiconductor | MC74HC1G00DTT1G | U8 | 1 | http://www.digikey.jp/product-detail/ja/MC74HC1G00DTT1G/MC74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
 | A4982 | 24-TSSOP | Allegro MicroSystems, LLC | A4982SLPTR | U3,U2 | 2 | http://www.digikey.jp/product-detail/ja/allegro-microsystems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
 | MCP4461 | 20-TSSOP | Microchip Technology | MCP4461-103E/ST | U7 | 1 | http://www.digikey.jp/product-detail/ja/microchip-technology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
 | MCP4725 | SOT-23-6 | Microchip Technology | MCP4725A0T-E/CH | U6 | 1 | http://www.digikey.jp/product-detail/ja/microchip-technology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
 | STM32F205 | 64-LQFP | STMicroelectronics | STM32F205RBT6 | U1 | 1 | http://www.digikey.jp/product-search/ja?keywords=STM32F205RBT6
 | BSH105,215 | SOT-23 | NXP Semiconductors | BSH105 | TR1 | 1 | http://www.digikey.jp/product-detail/ja/nxp-semiconductors/BSH105,215/568-6215-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
 | BSS138 | SOT-23 | Fairchild Semiconductor | BSS138 | Q1,Q2 | 2 | http://www.digikey.jp/product-detail/ja/fairchild-semiconduc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
 | Tact Switch | DHT-1163S | D.O Electronics Co.,Ltd | DHT-1163S | SW1 | 1 | http://www.seeedstudio.com/depot/images/opl/datasheet/311020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
 | DIP Switch | MS-22D18 | DG De Yi Long Electronics Hardware Limited | MS-22D18 G2 | SW2 | 1 | http://www.seeedstudio.com/depot/images/opl/datasheet/301001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
 | ESD
 | VARISTOR 0603 | 0603 | Bourns Inc. | CG0603MLC-05E | VR1,VR2 | 2 | http://www.digikey.jp/product-detail/ja/bourns-inc/CG0603MLC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
 | Ferrite bead
 | 220Ω@100MHz, 700mA | 0603 | Laird-Signal Integrity Products | LI0603G221R-10 | L1 | 1 | http://www.digikey.jp/product-detail/ja/LI0603G221R-10/240-2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
 | 220Ω@100MHz, 2A | 0805 | Murata Electronics North America | BLM21PG221SN1D | L2 | 1 | http://www.digikey.jp/product-detail/ja/murata-electronics-n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
 | Crystal
 | 25MHz, 18pF | 5032 | TXC CORPORATION | 7B-25.000MAAJ-T | X1 | 1 | http://www.digikey.jp/product-detail/ja/txc-corporation/7B-2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
 | RTC Crystal
 | 32.768KHz, 7pF | 2-SMD | TXC CORPORATION | 9HT10-32.768KDZY-T | X2 | 1 | http://www.digikey.jp/product-detail/ja/txc-corporation/9HT1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
 | LED
 | 2V, 3mA, Red | 0805 | Any | Any | D1,D2,D3,D4,D5,D8 | 6
 | 2V, 3mA, Green | 0805 | Any | Any | D7 | 1
 | 2V, 3mA, Blue | 0805 | Any | Any | D6 | 1
 | Ceramic Capacitor
 | 10p, Ceramic, 10V, 10% | 0603 | Any | Any | C24,C30 | 2
 | 20p, Ceramic, 10V, 10% | 0603 | Any | Any | C19,C22 | 2
 | 0u1, Ceramic, 10V, 10% | 0603 | Any | Any | C11,C12,C13,C14,C17,C18,C20,C21,C26,C27,C28,C29,C31,C33,C36,C38 | 16
 | 0u22, Ceramic, 10, 10% | 0603 | Any | Any | C1,C2,C9,C10 | 4
 | 2u2, Ceramic, 10V, 10% | 0603 | Any | Any | C15,C16 | 2
 | 1u, Ceramic, 10V, 10% | 0603 | Any | Any | C35 | 1
 | 0u1, Ceramic, 16V, 10% | 0805 | Any | Any | C3,C4,C7,C8,C23 | 5
 | 10u, Ceramic, 10V, 10% | 0805 | Any | Any | C32,C34,C37 | 3
 | Tantalum Capacitor
 | 10uF, 10V, 20% | 1206 | Any | Any | C25 | 1
 | Aluminum Capacitor
 | 100u, 35V, 20% | 6.3 x 7.7mm | Any | Any | C5,C6,C39 | 3 | http://www.digikey.jp/product-detail/ja/UWT1V101MCL1GS/493-2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
 | Resistor
 | 0R, 1/10W | 0603 | Any | Any | R6,R7 | 2
 | 22R, 1/10W, 5% | 0603 | Any | Any | R39,R40 | 2
 | 47R, 1/10W, 5% | 0603 | Any | Any | R34 | 1
 | 100R, 1/10W, 5% | 0603 | Any | Any | R41 | 1
 | 390R, 1/10W, 5% | 0603 | Any | Any | R36 | 1
 | 470R, 1/10W, 5% | 0603 | Any | Any | R16,R17,R18,R25,R26,R45 | 6
 | 1k5, 1/10W, 5% | 0603 | Any | Any | R44 | 1
 | 2k7, 1/10W, 5% | 0603 | Any | Any | R32 | 1
 | 4k7, 1/10W, 5% | 0603 | Any | Any | R28,R31,R43 | 3
 | 10k, 1/10W, 5% | 0603 | Any | Any | R1,R3,R5,R12,R13,R14,R15,R19,R20,R21,R22,R23,R24,R29,R30,R37,R38,R42 | 18
 | 100k, 1/10W, 5% | 0603 | Any | Any | R2,R4 | 2
 | 0R1, 1W, 5% | 1206 | Any | Any | R8,R9,R10,R11 | 4
 | 1k5, 1/2W, 5% | 1206 | Any | Any | R35 | 1
 | Connector
 | USB Type B Connector | USB - B | Any | Any | J4 | 1 | http://www.digikey.jp/product-detail/ja/on-shore-technology-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
 | 2P Connector |  | JST Sales America Inc | B2B-XH-A(LF)(SN) | J5,J6,J7,J8,J9,J15,J16,J17,J18,J19,J20 | 11
 | 3P Connector |  | JST Sales America Inc | B3B-XH-A(LF)(SN) | J10,J13 | 2
 | 4P Connector |  | JST Sales America Inc | B4B-XH-A(LF)(SN) | J11,J12,J14 | 3
 | Other
 | Heat Sink |  | Shenzhen S-mart Electronics Co.,Ltd | Heatsink 8.8*8.8*5mm with 3m thermal conductivity double-sided tape |  | 2

## Commit log

2016-08-25 :neckbeard: Added .gitattributes
2016-09-27 サンプル確認後の修正
    #16
    #15
    #14
    #13
    #12
2016-09-27 ガーバーデーター更新
2016-10-05 add datasheet
2016-10-05 シルク文字修正
2016-10-17 BOMにヒートシンク追加
2017-01-05 ノイズ対策
2017-01-19 ノイズ対策2
2017-01-20 hot fix
2017-01-27 元に戻す
2017-09-13 穴位置を0.5移動
2018-01-18 ねじ穴周辺レジスト除去
2018-08-08 Create LICENSE
